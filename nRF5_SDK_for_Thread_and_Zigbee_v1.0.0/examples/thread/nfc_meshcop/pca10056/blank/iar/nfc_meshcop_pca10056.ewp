# IAR project nfc_meshcop_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; OPENTHREAD_ENABLE_APPLICATION_COAP; SWI_DISABLE0; UART_ENABLED=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\bsp\experimental; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\experimental\meshcop; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nfc_meshcop_pca10056.hex
  ILINK.IlinkOutputFile: nfc_meshcop_pca10056.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\external\openthread\linker_scripts\openthread_nrf52840.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nrf_cc310
    ../../../../../../external/nrf_cc310/lib/: libnrf_cc310_short_wchar_0.9.9.a
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c
  group openthread
    ../../../../../../external/openthread/lib/iar/: libopenthread-cli-ftd.a libopenthread-ftd.a libopenthread-platform-utils.a libopenthread-nrf52840-sdk.a libopenthread-diag.a libmbedcrypto.a
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c
    ../../../../../../components/libraries/bsp/experimental/: bsp_thread.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_NFC
    ../../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../components/nfc/ndef/experimental/meshcop/: nfc_meshcop_msg.c nfc_meshcop_rec.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_iar.a
  group nRF_Thread
    ../../../../../../components/thread/utils/: thread_assert.c thread_utils.c
