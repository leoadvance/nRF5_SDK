# Keil uVision project ble_thread_dyn_mtd_coap_cli_nfc_pca10056_s140.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_UART_DRIVER_INSTANCE=1 BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRFX_PRS_ENABLED=0 NRF_SD_BLE_API_VERSION=6 OPENTHREAD_ENABLE_APPLICATION_COAP OPENTHREAD_MTD=1 S140 SOFTDEVICE_PRESENT SWI_DISABLE0 UART0_ENABLED=0 UART1_ENABLED=1 __HEAP_SIZE=0 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\bsp\experimental;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\..\components\libraries\experimental_mpu;..\..\..\..\..\..\..\components\libraries\experimental_ringbuf;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\experimental_stack_guard;..\..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t;..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\..\..\components\thread\utils;..\..\..\..\..\..\thread\app_utils;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\openthread\include;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_UART_DRIVER_INSTANCE=1,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRFX_PRS_ENABLED=0,-DNRF_SD_BLE_API_VERSION=6,-DOPENTHREAD_ENABLE_APPLICATION_COAP,-DOPENTHREAD_MTD=1,-DS140,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DUART0_ENABLED=0,-DUART1_ENABLED=1,-D__HEAP_SIZE=0,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xd6000
  memory RVCT9: RAM 0x20002a98 size 0x3d568
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
    ../../../../../../../components/libraries/bsp/experimental/: bsp_thread.c
  group Example
    ../../../../../../thread/app_utils/: thread_coap_utils.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/ecc/: ecc.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_NFC
    ../../../../../../../components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_oob_advdata/: nfc_ble_oob_advdata.c
    ../../../../../../../components/nfc/ndef/connection_handover/common/: nfc_ble_pair_common.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_lib/: nfc_ble_pair_lib.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_msg/: nfc_ble_pair_msg.c
    ../../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_keil.lib
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Thread
    ../../../../../../../components/thread/utils/: thread_assert.c thread_utils.c
  group nRF_micro-ecc
    ../../../../../../../external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/: nrf_cc310_keil_0.9.9.lib
  group openthread
    ../../../../../../../external/openthread/lib/keil/: libopenthread-cli-mtd.lib libopenthread-mtd.lib libopenthread-platform-utils.lib libopenthread-nrf52840-softdevice-sdk.lib libopenthread-diag.lib libmbedcrypto.lib
target flash_s140_nrf52_6.0.0_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s140_nrf52_6.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=0 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xd6000
  memory RVCT9: RAM 0x20002a98 size 0x3d568
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.16.0
