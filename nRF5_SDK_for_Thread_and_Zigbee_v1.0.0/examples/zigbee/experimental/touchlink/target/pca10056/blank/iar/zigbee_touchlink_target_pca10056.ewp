# IAR project zigbee_touchlink_target_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; ZB_ROUTER_ROLE; ZB_TRACE_LEVEL
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\..\external\zboss\include; ..\..\..\..\..\..\..\..\external\zboss\include\ha; ..\..\..\..\..\..\..\..\external\zboss\include\osif; ..\..\..\..\..\..\..\..\external\zboss\include\zcl; ..\..\..\..\..\..\..\..\external\zboss\include\zll; ..\..\..\..\..\..\..\..\external\zboss\osif; ..\..\..\..\..\..\..\..\external\zboss\zb_error; ..\..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_touchlink_target_pca10056.hex
  ILINK.IlinkOutputFile: zigbee_touchlink_target_pca10056.out
  ILINK.IlinkIcfFile: zigbee_touchlink_target_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group zigbee
    ../../../../../../../../external/zboss/lib/iar/: libzboss.a nrf_radio_driver.a
    ../../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_ppi.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
