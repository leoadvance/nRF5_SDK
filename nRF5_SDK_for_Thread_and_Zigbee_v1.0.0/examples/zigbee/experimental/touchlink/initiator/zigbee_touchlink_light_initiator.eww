<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\zigbee_touchlink_light_initiator_pca10056.ewp</path>
  </project>  <batchBuild/>
</workspace>